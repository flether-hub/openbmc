# Include ipmitool for IPMI command line access
# Useful for direct PECI, sensor, and FRU management
